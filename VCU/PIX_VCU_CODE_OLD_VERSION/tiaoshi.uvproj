# Keil uVision project tiaoshi.uvproj, settings and files
target Target 1 (166/167)
  device: XC2267M-104F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xA000-0xDFFF) XRAM2(0xE00000-0xE07FFF) IROM(0xC00000-0xC0EFFF) IROM2(0xC10000-0xCCFFFF) CLOCK(80000000) MOD167 MODV2
  output: tiaoshi
  group Dave Files
    ./source/: ADC0.c ADC1.c CAN.c CC2.c FUNC0.c GPT1.c GPT2.c IO.c MC33993.C SCS.c U0C0.c U0C1.c U1C0.c U2C0.c USIC0.c USIC1.c USIC2.c VARI0.c VEHI0.c
  group User Files
    ./source/: breaking_control.c differential_control.c MAIN.c speed_control.c steering.c vehicle_control.c pid_controler.c
